SUMMARY = "ISOBlue image with Docker runtime for Apalis IMX 6"
DESCRIPTION = "ISOBlue image, featuring complete Docker runtime and secure \
OTA update capabilities."

require recipes-images/images/torizon-core-docker.bb
